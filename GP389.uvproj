# Keil uVision project GP389.uvproj, settings and files
target Target 1 (MCS-51)
  device: M8051EW Mentor Graphics Co.
  cpu: IRAM(0 - 0xFF) XRAM(0-0xFFFF) IROM(0-0xFFFF) CLOCK(12000000) MOD517DP
  output: GP389 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\include
  group Source Group 1
    ./: STARTUP.A51
    ./source/: app_main.c boot.c bt_mode.c Flash.c key.c main.c rgb.c uart.c update.c voice_ic.c wifi_mode.c define.c PWM.c
